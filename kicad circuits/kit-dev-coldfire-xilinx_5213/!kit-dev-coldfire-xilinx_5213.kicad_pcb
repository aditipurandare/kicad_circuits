# Repository aditipurandare/kicad_circuits

## KiCad design kicad circuits/kit-dev-coldfire-xilinx_5213/!kit-dev-coldfire-xilinx_5213.kicad_pcb

Board: 4 copper layers, 157.5 x 91.4 mm, 162 parts (0 on the bottom side), 209 nets.

Parts:
ABRT_SW1: SW_PUSH; SW_PUSH_SMALL
ALLPST1: CONN_1; PinHeader_1x01_P2.54mm_Vertical
BDM_EN1: JUMPER; PinHeader_1x02_P2.54mm_Vertical
BDM_PORT1: CONN_13X2; PinHeader_2x13_P2.54mm_Vertical
C1, C2: 10pF; R_0805_2012Metric
C3, C20: 1nF; R_0805_2012Metric
C4, C5, C6, C7, C8, C9, C10, C11, C12, C14, C15, C18, C21, C22, C23, C24, C25, C26, C27, C28, C30, C31, C32, C33, C34, C35, C36, C41, C43, C44, C45, C46, C51, C52, C53, C54, C55, C56, C57, C58, C59, C60, C61: 100nF; R_0805_2012Metric
C16: 10uF; SM1206POL
C17: 100uF; SM1206POL
C38: 10uF; CP_Radial_D8.0mm_P5.00mm
C40: 220uF; CP_Radial_D8.0mm_P5.00mm
CAN_EN1: CONN_2X2; PinHeader_2x02_P2.54mm_Vertical
CAN_TERM1: JUMPER; PinHeader_1x02_P2.54mm_Vertical
CLK0, CLK1: JUMPER; PinHeader_1x02_P2.54mm_Vertical
CLKOUT1: CONN_1; PinHeader_1x01_P2.54mm_Vertical
COM_SEL1, COM_SEL2, COM_SEL3: CONN_3; PinHeader_1x03_P2.54mm_Vertical
CT1: JUMPER; PinHeader_1x02_P2.54mm_Vertical
D1, D3: BAT54; D_SOT-23_ANK
D7: 1N4004; D_DO-15_P12.70mm_Horizontal
D8, D9: LED; LED_1206_3216Metric
F1: FUSE; FSUPCMS
FB1: BEAD; R_1206_3216Metric_Pad1.24x1.80mm_HandSolder
GND1: CONN_1; PinHeader_1x01_P2.54mm_Vertical
J1: JACK_2P; JACK_ALIM
L1, L2: 10uH; R_1206_3216Metric_Pad1.24x1.80mm_HandSolder
LED1, LED2, LED3, LED4, LED5: LED; LED_1206_3216Metric
LEDABRT1: RED; SM1206POL
LED_EN1: JUMPER; PinHeader_1x02_P2.54mm_Vertical
LV1: DS1818; TO-92_Molded_Narrow
MCU_PORT1: CONN_30X2; PinHeader_2x30_P2.54mm_Vertical
P1: CONN_6; PinHeader_1x06_P2.54mm_Vertical
P3: CONN_2X2; PinHeader_2x02_P2.54mm_Vertical
P4: CONN_20X2; PinHeader_2x20_P2.54mm_Vertical
PULUPEN1: CONN_4X2; PinHeader_2x04_P2.54mm_Vertical
Q1: 3906; SOT23EBC
R1: 1M; R_0805_2012Metric
R2, R15, R16, R17, R18, R19, R20, R25, R45, R47, R48, R49, R50: 4,7K; R_0805_2012Metric
R4, R5, R6, R8, R10, R11, R13, R23, R26, R30, R34, R35: 10K; R_0805_2012Metric
R7, R36, R62, R63: 1K; R_0805_2012Metric
R9: 0; R_0805_2012Metric
R12: 20K; R_0805_2012Metric
R14, R22, R28, R31, R32, R33, R53: 270; R_0805_2012Metric
R21: 4.7K; R_0805_2012Metric
R38: 62; R_0805_2012Metric
R46: 22; R_0805_2012Metric
R57: 4K7; R_0805_2012Metric
R64: 3,3; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RCAN1, RCAN2: R; R_0805_2012Metric
RED1: LED_RESET1; SM1206POL
RS1: CONN_1; PinHeader_1x01_P2.54mm_Vertical
RST_SW1: SW_PUSH; SW_PUSH_SMALL
SW1, SW2: SW_PUSH; SW_PUSH_SMALL
SW_ONOFF1: SWITCH_INV; SW_SPDT
TA-1: CONN_1; PinHeader_1x01_P2.54mm_Vertical
TB1: CONN_2; bornier2
U1: MCF5213-LQFP100; LQFP-100_14x14mm_P0.5mm
U2: 74AHC1G14; SOT353
U3, U5, U8: MAX202; SOIC-16_3.9x9.9mm_P1.27mm
U4: 74HC125; SOIC-14_3.9x8.7mm_P1.27mm
U7: PCA82C251; SOIC-8_3.9x4.9mm_P1.27mm
U9: XCR3256-TQ144; TQFP-144_20x20mm_P0.5mm
UARTCAN0, UARTCAN1, UARTCAN2: DB9; DB9FC
UART_EN0, UART_EN1, UART_EN2: CONN_4X2; PinHeader_2x04_P2.54mm_Vertical
VDDA1: JUMPER; PinHeader_1x02_P2.54mm_Vertical
VR1: LT1129_QPACK; TO-263-5_TabPin3
VREF1: CONN_1; PinHeader_1x01_P2.54mm_Vertical
VX_EN1: JUMPER; PinHeader_1x02_P2.54mm_Vertical
Y1: 8MHz; Crystal_HC18-U_Horizontal

Connections:
+3.3V: ABRT_SW1.2, BDM_PORT1.9, BDM_PORT1.25, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C14.2, C17.1, C22.1, C23.1, C26.1, C28.1, C30.1, C34.1, C35.1, C40.1, C46.1, C51.1, C52.1, C53.1, C54.1, C55.1, C56.1, C57.1, C58.1, C59.1, C60.1, C61.1, L2.1, LEDABRT1.1, LV1.2, MCU_PORT1.59, P1.1, Q1.1, R2.1, R4.2, R5.2, R6.2, R8.2, R10.2, R11.2, R13.2, R15.1, R16.1, R17.1, R18.1, R19.1, R20.1, R25.1, R34.1, R45.2, R47.1, R48.1, R49.1, R50.1, R53.2, R57.1, R64.1, RCAN1.1, U1.1, U1.2, U1.14, U1.22, U1.23, U1.34, U1.41, U1.55, U1.57, U1.68, U1.81, U1.93, U2.5, U3.16, U4.14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
/ALLPST: ALLPST1.1, U1.86
/AN0: MCU_PORT1.10, U1.43
/AN1: MCU_PORT1.12, U1.44
/AN2: MCU_PORT1.14, U1.45
/AN3: MCU_PORT1.16, U1.46
/AN4: MCU_PORT1.18, U1.54
/AN5: MCU_PORT1.20, U1.53
/AN6: MCU_PORT1.22, U1.52
/AN7: MCU_PORT1.24, U1.51
/BKPT-: BDM_PORT1.2, R17.2, U1.76
/CANRX: CAN_EN1.4, MCU_PORT1.28, PULUPEN1.7, U1.11
/CANTX: CAN_EN1.1, MCU_PORT1.26, PULUPEN1.5, U1.10
/CLKIN/EXTAL: C1.1, R1.2, U1.73, Y1.1
/CLKMOD0: CLK0.2, R25.2, U1.40
/CLKMOD1: CLK1.2, R2.2, U1.39
/DDAT0: BDM_PORT1.19, U1.77
/DDAT1: BDM_PORT1.18, U1.78
/DDAT2: BDM_PORT1.17, U1.83
/DDAT3: BDM_PORT1.16, U1.84
/DSCLK: BDM_PORT1.4, R18.2, U1.85
/DSI: BDM_PORT1.8, R19.2, U1.79
/DSO: BDM_PORT1.10, R20.2, U1.80
/DSPI_DOUT: MCU_PORT1.17, U1.17, U9.47
/DTIN0: MCU_PORT1.34, U1.36, U4.2
/DTIN1: MCU_PORT1.36, U1.37, U4.5
/DTIN2: MCU_PORT1.38, U1.31, U4.12
/DTIN3: MCU_PORT1.40, U1.32, U4.9
/GPT0: MCU_PORT1.49, U1.58
/GPT1: MCU_PORT1.50, U1.59
/GPT2: MCU_PORT1.51, U1.61
/GPT3: MCU_PORT1.52, U1.62
/IRQ-1: MCU_PORT1.2, R4.1, U1.87, U9.42
/IRQ-2: MCU_PORT1.8, R5.1, U1.88, U9.43
/IRQ-3: MCU_PORT1.31, R6.1, U1.89, U9.44
/IRQ-4: MCU_PORT1.33, R8.1, SW1.1, U1.90
/IRQ-5: MCU_PORT1.35, R10.1, SW2.1, U1.91
/IRQ-6: MCU_PORT1.37, R11.1, U1.94
/IRQ-7: D1.2, MCU_PORT1.39, R13.1, U1.95
/JTAG_EN: BDM_EN1.2, R16.2, U1.26
/PST0: BDM_PORT1.15, U1.65
/PST1: BDM_PORT1.14, U1.66
/PST2: BDM_PORT1.13, U1.69
/PST3: BDM_PORT1.12, U1.70
/PWM1: MCU_PORT1.13, U1.38
/PWM3: MCU_PORT1.15, U1.33
/PWM5: MCU_PORT1.30, U1.60
/PWM7: MCU_PORT1.32, U1.63
/QSPI_CLK: MCU_PORT1.21, PULUPEN1.1, U1.18, U9.48
/QSPI_CS0: MCU_PORT1.23, PULUPEN1.3, U1.20
/QSPI_CS1: MCU_PORT1.25, U1.19, U9.54
/QSPI_CS2: MCU_PORT1.27, U1.13, U9.45
/QSPI_CS3: MCU_PORT1.29, U1.12
/QSPI_DIN: MCU_PORT1.19, U1.16, U9.46
/RCON-: MCU_PORT1.53, R45.1, U1.21
/RSTI-: BDM_PORT1.7, D3.2, MCU_PORT1.6, R15.2, U1.96
/RSTO-: MCU_PORT1.4, R21.1, U1.97
/TCLK: BDM_PORT1.24, CLKOUT1.1, CT1.2, R26.1, R46.2
/UCTS0: MCU_PORT1.44, U1.6, UART_EN0.8
/UCTS1: MCU_PORT1.11, P3.1, U1.98, U9.49, UART_EN1.8
/UCTS2: MCU_PORT1.48, U1.27, UART_EN2.8
/URTS0: MCU_PORT1.42, U1.9, UART_EN0.6
/URTS1: MCU_PORT1.9, P3.3, U1.4, U9.53, UART_EN1.6
/URTS2: MCU_PORT1.46, U1.30, UART_EN2.6
/URXD0: MCU_PORT1.43, U1.7, UART_EN0.4
/URXD1: MCU_PORT1.7, U1.100, UART_EN1.4
/URXD2: MCU_PORT1.47, U1.28, UART_EN2.4
/UTXD0: MCU_PORT1.41, U1.8, UART_EN0.2
/UTXD1: MCU_PORT1.5, U1.99, UART_EN1.2
/UTXD2: MCU_PORT1.45, U1.29, UART_EN2.2
/VCCA: C16.1, C18.1, L1.2, MCU_PORT1.55, MCU_PORT1.57, U1.49, U1.50
/VDDPLL: C20.1, C21.1, L2.2, U1.74
/XTAL: C2.1, R1.1, U1.72, U9.128, Y1.2
/inout_user/CAN_H: CAN_TERM1.1, COM_SEL1.1, RCAN2.2, U7.7
/inout_user/CAN_L: COM_SEL3.1, R38.1, RCAN1.2, U7.6
/inout_user/CTS0: U3.8, UARTCAN0.7
/inout_user/CTS1: U5.8, UARTCAN1.7
/inout_user/CTS2/CANH: COM_SEL1.2, UARTCAN2.7
/inout_user/RTS0: U3.7, UARTCAN0.8
/inout_user/RTS1: U5.7, UARTCAN1.8
/inout_user/RTS2: U8.14, UARTCAN2.8
/inout_user/RXD0: U3.13, UARTCAN0.3
/inout_user/RXD1: U5.13, UARTCAN1.3
/inout_user/RXD2: COM_SEL2.2, UARTCAN2.3
/inout_user/RxD_CAN: CAN_EN1.2, U7.4
/inout_user/TXD0: U3.14, UARTCAN0.2
/inout_user/TXD1: U5.14, UARTCAN1.2
/inout_user/TXD2/CANL: COM_SEL3.2, UARTCAN2.2
/inout_user/TxD_CAN: CAN_EN1.3, U7.1
/xilinx/+3,3V_OUT: P4.38, R64.2
/xilinx/LED_TEST1: R62.1, U9.28
/xilinx/LED_TEST2: R63.1, U9.27
/xilinx/TCK: P1.5, R57.2, U9.89
/xilinx/TDI: P1.4, U9.4
/xilinx/TDO: P1.6, U9.104
/xilinx/TMS: P1.3, U9.20
/xilinx/XIL_D0: P4.1, U9.12
/xilinx/XIL_D1: P4.3, U9.11
/xilinx/XIL_D2: P4.5, U9.7
/xilinx/XIL_D3: P4.7, U9.8
/xilinx/XIL_D4: P4.9, U9.2
/xilinx/XIL_D5: P4.11, U9.143
/xilinx/XIL_D6: P4.13, U9.140
/xilinx/XIL_D7: P4.15, U9.138
/xilinx/XIL_D8: P4.17, U9.136
/xilinx/XIL_D9: P4.19, U9.131
/xilinx/XIL_D10: P4.21, U9.122
/xilinx/XIL_D11: P4.23, U9.119
/xilinx/XIL_D12: P4.25, U9.114
/xilinx/XIL_D13: P4.27, U9.111
/xilinx/XIL_D14: P4.29, U9.109
/xilinx/XIL_D15: P4.31, U9.108
/xilinx/XIL_D16: P4.33, U9.100
/xilinx/XIL_D17: P4.35, U9.101
/xilinx/XIL_D18: P4.37, U9.97
/xilinx/XIL_D19: P4.39, U9.96
/xilinx/XIL_D20: P4.4, U9.6
/xilinx/XIL_D21: P4.6, U9.10
/xilinx/XIL_D22: P4.8, U9.5
/xilinx/XIL_D23: P4.10, U9.1
/xilinx/XIL_D24: P4.12, U9.142
/xilinx/XIL_D25: P4.14, U9.139
/xilinx/XIL_D26: P4.16, U9.137
/xilinx/XIL_D27: P4.18, U9.134
/xilinx/XIL_D28: P4.20, U9.132
/xilinx/XIL_D29: P4.22, U9.117
/xilinx/XIL_D30: P4.24, U9.118
/xilinx/XIL_D31: P4.26, U9.116
/xilinx/XIL_D32: P4.28, U9.98
/xilinx/XIL_D33: P4.30, U9.112
/xilinx/XIL_D34: P4.32, U9.113
/xilinx/XIL_D35: P4.34, U9.107
/xilinx/XIL_D36: P4.36, U9.99
GND: BDM_EN1.1, BDM_PORT1.3, BDM_PORT1.5, BDM_PORT1.11, BDM_PORT1.20, BDM_PORT1.23, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C14.1, C15.2, C17.2, C20.2, C21.2, C22.2, C26.2, C27.2, C28.2, C33.2, C34.2, C38.2, C40.2, C41.2, C43.1, C45.2, C46.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, CLK0.1, CLK1.1, COM_SEL2.1, D7.2, D8.2, D9.2, FB1.1, GND1.1, J1.1, J1.2, LED1.2, LED2.2, LED3.2, LED4.2, LED5.2, LED_EN1.1, LV1.3, MCU_PORT1.3, MCU_PORT1.54, MCU_PORT1.60, P1.2, P4.2, P4.40, R9.2, R12.2, R23.1, R26.2, R30.1, R35.1, R36.2, RCAN2.1, RED1.2, RST_SW1.2, SW1.2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
GNDA: C16.2, C18.2, FB1.2, MCU_PORT1.56, MCU_PORT1.58, U1.47, U1.48
unnamed: ABRT_SW1.1, R7.1
unnamed: BDM_PORT1.6, CT1.1
unnamed: BDM_PORT1.26, TA-1.1
unnamed: C3.1, D3.1, LV1.1, RST_SW1.1
unnamed: C15.1, R7.2, R12.1, U2.2
unnamed: C23.2, U3.2
unnamed: C24.1, U3.1
unnamed: C24.2, U3.3
unnamed: C25.1, U3.4
unnamed: C25.2, U3.5
unnamed: C27.1, U3.6
unnamed: C30.2, U5.2
unnamed: C31.1, U5.1
unnamed: C31.2, U5.3
unnamed: C32.1, U5.4
unnamed: C32.2, U5.5
unnamed: C33.1, U5.6
unnamed: C35.2, U8.2
unnamed: C36.1, U8.4
unnamed: C36.2, U8.5
unnamed: C38.1, C41.1, D7.1, F1.2, VR1.5
unnamed: C43.2, MCU_PORT1.1, VX_EN1.2
unnamed: C44.1, U8.1
unnamed: C44.2, U8.3
unnamed: C45.1, U8.6
unnamed: CAN_TERM1.2, R38.2
unnamed: COM_SEL1.3, U8.13
unnamed: COM_SEL2.3, U8.8
unnamed: COM_SEL3.3, U8.7
unnamed: D1.1, R14.2, U2.4
unnamed: D8.1, R62.2
unnamed: D9.1, R63.2
unnamed: F1.1, SW_ONOFF1.2
unnamed: J1.3, SW_ONOFF1.3, TB1.1
unnamed: L1.1, VDDA1.2
unnamed: LED1.1, R28.1
unnamed: LED2.1, R31.1
unnamed: LED3.1, R32.1
unnamed: LED4.1, R33.1
unnamed: LED5.1, R53.1
unnamed: LEDABRT1.2, R14.1
unnamed: LED_EN1.2, R34.2, U4.1, U4.4, U4.10, U4.13
unnamed: P3.2, U9.32
unnamed: P3.4, U9.31
unnamed: PULUPEN1.2, R50.2
unnamed: PULUPEN1.4, R49.2
unnamed: PULUPEN1.6, R48.2
unnamed: PULUPEN1.8, R47.2
unnamed: Q1.2, R21.2
unnamed: Q1.3, R22.1
unnamed: R9.1, U1.5
unnamed: R22.2, RED1.1
unnamed: R23.2, U8.11, UART_EN2.5
unnamed: R28.2, U4.3
unnamed: R30.2, U3.10, UART_EN0.5
unnamed: R31.2, U4.6
unnamed: R32.2, U4.11
unnamed: R33.2, U4.8
unnamed: R35.2, U5.10, UART_EN1.5
unnamed: R36.1, RS1.1, U7.8
unnamed: R46.1, U1.64
unnamed: U3.9, UART_EN0.7
unnamed: U3.11, UART_EN0.1
unnamed: U3.12, UART_EN0.3
unnamed: U5.9, UART_EN1.7
unnamed: U5.11, UART_EN1.1
unnamed: U5.12, UART_EN1.3
unnamed: U7.5, VREF1.1
unnamed: U8.9, UART_EN2.3
unnamed: U8.10, UART_EN2.1
unnamed: U8.12, UART_EN2.7
unnamed: UARTCAN0.1, UARTCAN0.4, UARTCAN0.6
unnamed: UARTCAN1.1, UARTCAN1.4, UARTCAN1.6
unnamed: UARTCAN2.1, UARTCAN2.4, UARTCAN2.6

## KiCad design kicad circuits/sonde xilinx/!sonde xilinx.kicad_pcb

Board: 2 copper layers, 81.3 x 43.2 mm, 25 parts (0 on the bottom side), 26 nets, no tracks yet.

Parts:
C1: 1uF; C_Axial_L5.1mm_D3.1mm_P12.50mm_Horizontal
C2, C3, C4, C5: 100pF; C_Disc_D5.1mm_W3.2mm_P5.00mm
D1, D2: BAT46; D_A-405_P7.62mm_Horizontal
J1: DB25MALE; DSUB-25_Male_EdgeMount_P2.77mm
J2: DB9MALE; DSUB-9_Male_EdgeMount_P2.77mm
P1: CONN_6; PinHeader_1x06_P2.54mm_Vertical
R1, R6, R7, R8, R9, R10, R11, R12, R13, R14: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 5,1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 47; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1, U2: 74LS125; DIP-14_W7.62mm_LongPads

Connections:
/CLK-D1: J1.3, R10.2
/CTRL-D3: J1.5, R8.2
/DONE-SELECT*: J1.13, R4.2
/PWR_3,3-5V: D2.1, J2.1, P1.1
/TCK-CCLK: J2.4, P1.5, R12.1
/TD0-DONE: J2.2, P1.3, R14.1
/TD0-PROG-D4: J1.6, R6.2
/TDI-DIN: J2.3, P1.4, R11.1
/TDI-DIN-D0: J1.2, R7.2
/TMS-PROG: J2.5, P1.6, R13.1
/TMS-PROG-D2: J1.4, R9.2
/VCC_SENSE-ERROR*: J1.15, R1.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, J1.20, J1.25, J2.6, J2.7, J2.8, J2.9, P1.2, R5.2, U1.2, U1.7, U2.1, U2.4, U2.5, U2.7, U2.9, U2.10, U2.12, U2.13
unnamed: C2.1, R11.2, U1.6
unnamed: C3.1, R2.2, R14.2, U1.3, U2.2
unnamed: C4.1, R13.2, U1.11
unnamed: C5.1, R12.2, U1.8
unnamed: D1.2, R1.1
unnamed: J1.8, J1.11, J1.12
unnamed: R4.1, U2.3
unnamed: R6.1, U1.1
unnamed: R7.1, U1.5
unnamed: R8.1, U1.4, U1.10, U1.13
unnamed: R9.1, U1.12
unnamed: R10.1, U1.9
VCC: C1.1, D1.1, D2.2, R2.1, R5.1, U1.14, U2.14

## KiCad design kicad circuits/test_xil_95108/!carte_test.kicad_pcb

Board: 2 copper layers, 101.6 x 99.7 mm, 42 parts (9 on the bottom side), 83 nets.

Parts:
C1, C12: 100nF; C_1206
C2, C3, C13, C14: 10uF; CP_Axial_L10.0mm_D4.5mm_P15.00mm_Horizontal
C4, C5: 22pF; C_1206
C6: 47uF; CP_Axial_L10.0mm_D4.5mm_P15.00mm_Horizontal
C7, C8, C10, C11: 100nF; C_1206_3216Metric_Pad1.24x1.80mm_HandSolder
D1, D4: 1N4004; D_DO-35_SOD27_P12.70mm_Horizontal
D2, D3: LED; LED_D5.0mm
J1: DB25; DSUB-25_Female_Horizontal_P2.77x2.84mm_EdgePinOffset9.90mm_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
J2: DB9FEM; DSUB-9_Female_EdgeMount_P2.77mm
K1: CONN_3; Socket_Strip_Straight_1x03
P2: CONN_3; TerminalBlock_Phoenix_MKDS-1,5-3-5.08_1x03_P5.08mm_Horizont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
P3: CONN_2; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
P4: CONN_2X2; PinHeader_2x02_P2.54mm_Vertical
R1: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R3: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4, R5: 4,7K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6: 1,1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7: 1,1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R8, R9: 2,2K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R10: 75; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1, SW2: SW_PUSH; SW_PUSH_6mm_h4.3mm
U1: TDA8702; DIP-16_W7.62mm_Socket_LongPads
U2: XC95108PC84; PLCC84
U3: LM7805; TO-220-3_Horizontal_TabDown
U4: 74HC04; DIP-14_W7.62mm_LongPads
U5: RAM_32KO; DIP-28__300__600_ELL
U6: LM318N; DIP-8_W7.62mm_LongPads
X1: 10MHz; Crystal_HC18-U_Horizontal

Connections:
+12V: C6.1, D1.1, U3.1, U6.7
-12V: C13.2, D4.2, U6.4
/+12BATT: D1.2, P2.1
/-12BATT: D4.1, P2.3
/CSMEM: U2.39, U5.20
/DAT0: U1.12, U2.69
/DAT1: U1.11, U2.66
/DAT2: U1.3, U2.70
/DAT3: U1.4, U2.68
/DAT4: U1.10, U2.63
/DAT5: U1.9, U2.61
/DAT6: U1.8, U2.58
/DAT7: U1.7, U2.62
/DCLK: U1.5, U2.67
/LED1: R2.2, U2.76
/LED2: R3.2, U2.74
/MA0: U2.33, U5.11
/MA1: U2.32, U5.12
/MA2: U2.26, U5.13
/MA3: U2.25, U5.15
/MA4: U2.24, U5.16
/MA5: U2.31, U5.17
/MA6: U2.34, U5.18
/MA7: U2.36, U5.19
/MD0: U2.35, U5.10
/MD1: U2.37, U5.9
/MD2: U2.40, U5.8
/MD3: U2.44, U5.7
/MD4: U2.46, U5.6
/MD5: U2.48, U5.5
/MD6: U2.50, U5.4
/MD7: U2.52, U5.3
/MD8: U2.51, U5.25
/MD9: U2.47, U5.24
/MD10: U2.41, U5.21
/MD11: U2.45, U5.23
/MD12: U2.55, U5.2
/MD13: U2.53, U5.26
/MD14: K1.3, U2.56
/OEMEM: U2.43, U5.22
/PARBUS0: J1.2, U2.10
/PARBUS1: J1.3, U2.7
/PARBUS2: J1.4, U2.5
/PARBUS3: J1.5, U2.3
/PARBUS4: J1.6, U2.84
/PARBUS5: J1.7, U2.83
/PARBUS6: J1.8, U2.81
/PARBUS7: J1.9, U2.82
/PAR_AUX0/STROBE*: J1.1, U2.13
/PAR_AUX1/ERROR*: J1.15, U2.9
/PAR_AUX2/AUTOLF*: J1.14, U2.11
/PAR_AUX3/SELECT*: J1.13, U2.75
/PAR_AUX4/PE: J1.12, U2.77
/PAR_AUX5/BUSY*: J1.11, U2.80
/PAR_AUX6/ACK: J1.10, U2.79
/PAR_AUX7/INIT: J1.16, U2.6
/PAR_AUX8/SELECT: J1.17, U2.4
/PIN_TEST0: P4.2, U2.1
/PIN_TEST1: P4.4, U2.2
/R/W-A14: U2.54, U5.27
/SW0: R5.2, SW1.1, U2.72
/SW1: R4.2, SW2.1, U2.71
/TCK: J2.4, U2.30
/TDI: J2.3, U2.28
/TDO: J2.2, U2.59
/TMS: J2.5, U2.29
/XIN/CLK: U2.12, U4.4
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C10.2, C11.2, C12.2, C13.1, D2.1, D3.1, J1.18, J1.19, J1.20, J1.21, J1.22, J1.23, J1.24, J1.25, J2.6, J2.7, J2.8, J2.9, P2.2, P3.2, P4.1, P4.3, R6.2, SW1.2, SW2.2, U1.2, U1.6, U2.8, U2.16, U2.27, U2.42, U2.49, U2.60, U3.2, U4.5, U4.7, U4.9, U4.11, U4.13, U5.14
unnamed: C1.1, U1.1
unnamed: C2.1, U1.14
unnamed: C2.2, R9.2
unnamed: C4.1, R1.1, U4.2, U4.3, X1.2
unnamed: C5.1, R1.2, U4.1, X1.1
unnamed: C14.1, U1.15
unnamed: C14.2, R8.2
unnamed: D2.2, R2.1
unnamed: D3.2, R3.1
unnamed: K1.2, U5.1
unnamed: P3.1, R10.1
unnamed: R6.1, R9.1, U6.3
unnamed: R7.2, R8.1, U6.2
unnamed: R7.1, R10.2, U6.6
VCC: C3.1, C7.1, C8.1, C10.1, C11.1, C12.1, J2.1, K1.1, R4.1, R5.1, U1.13, U1.16, U2.22, U2.38, U2.64, U2.73, U2.78, U3.3, U4.14, U5.28

## KiCad design kicad circuits/ecc83/ecc83-pp.kicad_pcb

Board: 2 copper layers, 5 parts (0 on the bottom side), 6 nets, no tracks yet.

Parts:
P1: IN; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
P2: OUT; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
P3: POWER; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
P4: CONN_2; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
U1: ECC83; Valve_ECC-83-1

Connections:
GND: P1.1, P2.2, P3.2
unnamed: P3.1, U1.6
unnamed: P1.2, U1.2
unnamed: P4.1, U1.9
unnamed: P4.2, U1.4, U1.5
unnamed: U1.1, U1.7

## KiCad design kicad circuits/ecc83/!e.kicad_pcb

Board: 2 copper layers, 44.5 x 45.7 mm, 15 parts (0 on the bottom side), 9 nets.

Parts:
C1: 10uF; C2V10
C2: 680nF; C2
P1: IN; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
P2: OUT; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
P3: POWER; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
P4: CONN_2; TerminalBlock_Phoenix_MKDS-1,5-2_1x02_P5.00mm_Horizontal
P5, P6, P7, P8: CONN_1; 1pin
R1, R2: 1.5K; R3
R3: 100K; R3
R4: 47K; R3
U1: ECC83; Valve_ECC-83-1

Connections:
GND: C1.2, P1.1, P2.2, P3.2, R2.2, R3.2, R4.2
unnamed: C1.1, P3.1, U1.6
unnamed: C2.1, P2.1, R3.1
unnamed: C2.2, R1.2, U1.8
unnamed: P1.2, R4.1, U1.2
unnamed: P4.1, U1.9
unnamed: P4.2, U1.4, U1.5
unnamed: R1.1, U1.1, U1.7
unnamed: R2.1, U1.3

## KiCad design kicad circuits/flat_hierarchy/flat_hierarchy_deleted.kicad_pcb

Board: 2 copper layers, 160.0 x 99.1 mm, 64 parts (0 on the bottom side), 34 nets, no tracks yet.

Parts:
1PIN, 1PIN#2, 1PIN#3, 1PIN#4, 1PIN#5, 1PIN#6: P***; 1pin
C1: 100uF; CP10
C2: 220uF; CP10
C3: 22uF/25V; CP8
C4: 0; C1-1
C5: 10nF; C1-1
C6, C7, C8: 100nF; C1-1
C9: 22OnF; C1-1
D1: 1N4004; D_DO-35_SOD27_P12.70mm_Horizontal
D2, D3, D4, D5, D6, D7, D11: BAT43; D_DO-35_SOD27_P7.62mm_Horizontal
D8: RED-LED; LEDV
D9: GREEN-LED; LEDV
D10: SCHOTTKY; D_DO-35_SOD27_P12.70mm_Horizontal
D12: YELLOW-LED; LEDV
J1: DB9-FEMAL; DB9FC
JP1: JUMPER; PIN_ARRAY_2X1
L1: 22uH; INDUCTOR_V
P1: CONN_2; bornier2
P2: SUPP28; 28DIP-ELL300
P3: SUPP40; 40DIP-ELL600
Q1: BC237; TO92
Q2, Q3: BC307; TO92
R1, R2, R3, R4, R5, R6, R7: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R8: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9, R19, R20: 2.2K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R10: 5.1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R11, R17: 22K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R12, R13, R14, R21: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R15: 6.2K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R16: 62K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R18: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV1: 1K; RV2X4
U1: 24Cxx; DIP-8__300_ELL
U2: 74HC125; DIP-14__300_ELL
U3: 7805; LM78XX
U4: LT1373; DIP-8__300_ELL
U5: PIC_18_PINS; DIP-18__300_ELL
U6: PIC_8_PINS; DIP-8__300_ELL

Connections:
/pic_programmer/CTS: J1.8, U2.11
/pic_programmer/DTR: J1.4, R3.1, R4.1
/pic_programmer/PC-CLOCK-OUT: J1.7, R5.1, R6.1
/pic_programmer/TXD: J1.3, R1.1, R2.1
CLOCK-RB6: P2.27, P3.39, R13.2, U1.6, U5.12, U6.6
DATA-RB7: P2.28, P3.40, R12.2, U1.5, U2.12, U5.13, U6.7
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D3.1, D5.2, D7.2, D8.2, D9.2, D12.2, J1.5, P1.1, P2.8, P2.19, P3.8, P3.12, P3.31, Q1.1, R2.2, R4.2, R6.2, R15.2, R17.2, U1.1, U1.2, U1.3, U1.4, U2.1, U2.4, U2.7, U2.10, U2.13, U3.GND, U4.6, U4.7, U5.5, U6.8
unnamed: C2.1, D1.1, U3.VI
unnamed: C4.1, R10.1, U4.1
unnamed: C5.1, R10.2
unnamed: C9.2, Q2.2, R7.2, R11.2
unnamed: D1.2, P1.2
unnamed: D2.1, D3.2, R1.2, U2.2
unnamed: D4.2, D5.1, R3.2, U2.5
unnamed: D6.2, D7.1, R5.2, U2.9
unnamed: D8.1, R9.2
unnamed: D9.1, R14.2
unnamed: D10.2, L1.1, U4.8
unnamed: D11.1, Q1.3, R11.1
unnamed: D11.2, R19.1
unnamed: D12.1, R21.2
unnamed: Q1.2, R8.2
unnamed: Q2.3, R9.1, R17.1, R18.1
unnamed: Q3.2, R19.2, R20.2
unnamed: R8.1, U2.3
unnamed: R12.1, U2.6
unnamed: R13.1, U2.8
unnamed: R15.1, RV1.1
unnamed: R16.1, RV1.3
unnamed: RV1.2, U4.2
VCC: C1.1, C6.1, D2.2, D4.1, D6.1, JP1.1, L1.2, Q3.1, R14.1, R20.1, U1.8, U2.14, U3.VO, U4.5
VCC_PIC: C7.1, C8.1, JP1.2, P2.20, P3.11, P3.32, Q3.3, R21.1, U5.14, U6.1
VPP: C3.1, C9.1, D10.1, Q2.1, R7.1, R16.2
VPP-MCLR: P2.1, P3.1, R18.2, U5.4, U6.4
