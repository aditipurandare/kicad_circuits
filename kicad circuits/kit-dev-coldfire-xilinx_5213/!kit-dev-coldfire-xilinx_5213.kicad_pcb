# Repository aditipurandare/kicad_circuits (continued)

## KiCad design kicad circuits/complex_hierarchy/complex_hierarchy_deleted.kicad_pcb

Board: 2 copper layers, 100.3 x 80.0 mm, 68 parts (0 on the bottom side), 50 nets, no tracks yet.

Parts:
C1: 47uF; CP6
C2: 47uF/20V; CP6
C3, C6: 15nF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C4, C7: 4.7nF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C5, C8: 820pF; C_Disc_D5.0mm_W2.5mm_P5.00mm
C9: 47uF/63V; CP8
C10, C11: 10uF; CP6
C12, C14: 150nF; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1: 1N4007; D_DO-41_SOD81_P12.70mm_Horizontal
D2, D3, D4, D5, D6, D7, D8, D9: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
P1, P2, P3, P4, P5, P6: CONN_2; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
Q1, Q3, Q5, Q7: MPAS92; TO92-CBE
Q2, Q4, Q6, Q8: MPAS42; TO92-CBE
R3, R13: 470; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R4, R12, R14, R22, R26, R28: 220K; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R5, R15, R25, R27: 47; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R6, R7, R16, R17: 22K; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R8, R9, R18, R19, R23, R24: 1K; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R10, R20: 5,6K; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R11, R21: 4,7K; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
RV1, RV2: 4,7K; RV2
U1: ICL7660; DIP-8_W7.62mm_LongPads
U2: 78L05; LM78LXX
U3, U4: LM358N; DIP-8_W7.62mm_LongPads

Connections:
+12C: C2.1, D1.1, U2.VI, U3.8, U4.8
-VAA: C11.2, U1.5, U3.4, U4.4
/12Vext: D1.2, P2.1
/ampli_ht_horizontal/PIEZO_IN: P6.1, R24.2
/ampli_ht_horizontal/PIEZO_OUT: P5.1, R15.1, R27.1
/ampli_ht_horizontal/S_OUT+: R22.1, R28.1, RV2.3
/ampli_ht_horizontal/Vpil_0_3,3V: C6.1, U4.3, U4.6, U4.7
/ampli_ht_vertical/PIEZO_IN: P4.1, R23.2
/ampli_ht_vertical/PIEZO_OUT: P3.1, R5.1, R25.1
/ampli_ht_vertical/S_OUT+: R12.1, R26.1, RV1.3
/ampli_ht_vertical/Vpil_0_3,3V: C3.1, U3.3, U3.6, U3.7
GND: C1.2, C2.2, C4.2, C5.2, C7.2, C8.2, C9.2, C11.1, C12.2, C14.2, P1.2, P2.2, P3.2, P4.2, P5.2, P6.2, Q3.C, Q7.C, R4.2, R8.2, R11.2, R14.2, R18.2, R21.2, U1.3, U2.GND
HT: C9.1, D2.2, D5.2, P1.1, Q2.C, Q6.C, R3.1, R13.1
unnamed: C3.2, R6.1, R7.2
unnamed: C4.1, R7.1, U3.5
unnamed: C5.1, R10.2
unnamed: C6.2, R16.1, R17.2
unnamed: C7.1, R17.1, U4.5
unnamed: C8.1, R20.2
unnamed: C10.1, U1.2
unnamed: C10.2, U1.4
unnamed: C12.1, R6.2, R23.1
unnamed: C14.1, R16.2, R24.1
unnamed: D2.1, D3.2
unnamed: D3.1, Q1.B, R4.1
unnamed: D4.1, Q3.B, Q4.C, R10.1
unnamed: D4.2, D8.1
unnamed: D5.1, D6.2
unnamed: D6.1, Q5.B, R14.1
unnamed: D7.1, Q7.B, Q8.C, R20.1
unnamed: D7.2, D9.1
unnamed: D8.2, Q1.C, Q2.B
unnamed: D9.2, Q5.C, Q6.B
unnamed: Q1.E, R3.2
unnamed: Q2.E, R5.2, R26.2
unnamed: Q3.E, R12.2, R25.2
unnamed: Q4.B, R8.1
unnamed: Q4.E, R9.1
unnamed: Q5.E, R13.2
unnamed: Q6.E, R15.2, R28.2
unnamed: Q7.E, R22.2, R27.2
unnamed: Q8.B, R18.1
unnamed: Q8.E, R19.1
unnamed: R9.2, U3.1
unnamed: R11.1, RV1.1
unnamed: R19.2, U4.1
unnamed: R21.1, RV2.1
unnamed: RV1.2, U3.2
unnamed: RV2.2, U4.2
VCC: C1.1, U1.8, U2.VO

## KiCad design kicad circuits/custom_pads_test1/!custom_pads_test.kicad_pcb

Board: 2 copper layers, 118.0 x 90.0 mm, 5 parts (0 on the bottom side), 3 nets.

Parts:
AE1, AE2: Antenna; 1pin
R2: R; DO-214AB
SW1: R; C2
U***: DIP-14_300_ELL; DIP-14__300_ELL

Connections:
/PAD1: R2.1, SW1.1
/PAD2: R2.2, SW1.2
GND: AE1.1, AE2.1

## Commit log

2020-02-14 Sample kicad circuits autorouted using freerouting.jar
